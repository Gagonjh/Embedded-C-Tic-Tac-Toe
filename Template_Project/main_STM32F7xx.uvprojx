# Keil uVision project main_STM32F7xx.uvprojx, settings and files
target Target (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: STM32F769NIHx STMicroelectronics
  pack: Keil.STM32F7xx_DFP.2.14.0
  cpu: IROM(0x08000000-0x081FFFFF) IRAM(0x20000000-0x2007FFFF) CPUTYPE("Cortex-M7") FPU3(SFPU) CLOCK(12000000) ELITTLE
  output: main +hex
  c flags: Optim=2 OneElfS=1 wLevel=2
  c define: _KEIL, STM32F769xx, _HSE_CLK=25000, _HSE_BYPASS_OFF, USE_GRAPHIC_DISPLAY
  c include: ..\Src;C:\Bin\Keil_v5\ARM\PACK\ARM\CMSIS\5.0.1\CMSIS\Include;.\..\EmbSysLib\Src\MCU\STM32F7xx;.\..\EmbSysLib\Src;.\Src
  memory RVCT4: ROM 0x8000000 size 0x200000
  memory RVCT5: ROM 0x200000 size 0x200000
  memory RVCT9: RAM 0x20020000 size 0x5c00
  memory RVCT10: RAM 0x2007c000 size 0x4000
  group Src
    ./Src/: main.cpp project_headers.h Field.cpp Field.h Token.cpp datatypes.h Token.h Controller.cpp Controller.h Cells.cpp Cells.h Game.cpp Game.h configSTM32F7xx.h Game_settings.cpp Game_settings.h History.cpp History.h Menue.cpp Menue.h pages.cpp pages.h Settings.cpp Settings.h Style.cpp Style.h Symbole.cpp Symbole.h
  group Lib
    ../EmbSysLib/Src/: lib.h lib.cpp
    ../EmbSysLib/Src/MCU/STM32F7xx/Sys/Keil/: RTOScontext.s startup_stm32f769xx.s
    ../EmbSysLib/Src/Module/: RTOS.h RTOS.cpp
    ../EmbSysLib/Src/Peripheral/: Disp_OTM8009A.h Disp_OTM8009A.cpp Touch_FT6206.h Touch_FT6206.cpp
